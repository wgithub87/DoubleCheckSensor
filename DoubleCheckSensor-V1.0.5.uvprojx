# Keil uVision project DoubleCheckSensor-V1.0.5.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: M0516ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: DoubleCheckSensor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: main.c
    ./Lib/src/: bsp_IntSer.c bsp_storage.c config.c handle.c bsp_stickless.c bsp_keyscan.c
software components: CMSIS:RTOS:Keil RTX 4.81.1, Device:Driver:ADC 3.01.002, Device:Driver:CLK 3.01.002, Device:Driver:FMC 3.01.002, Device:Driver:GPIO 3.01.002, Device:Driver:SYS 3.01.002, Device:Driver:Timer 3.01.002, Device:Driver:WDT 3.01.002, Device:Startup 3.01.002
